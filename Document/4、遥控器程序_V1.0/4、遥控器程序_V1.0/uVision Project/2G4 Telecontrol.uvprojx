# Keil uVision project 2G4 Telecontrol.uvprojx, settings and files
target 遥控手柄_V1.0 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 2G4 Telecontrol +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Core;..\System;..\FWLib\inc;..\Code_User\@bit_band;..\Code_User\@delay;..\Code_User\LED;..\Code_User\KEY;..\Code_User\OLED;..\Code_User\TIMER;..\Code_User\ADC;..\Code_User\SPI;..\Code_User\RF2G4;..\Code_User\DMA
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Code_User
    ../Code_User/: main.c
    ../Code_User/@delay/: delay.c
    ../Code_User/LED/: led.c
    ../Code_User/KEY/: key.c
    ../Code_User/OLED/: oled.c
    ../Code_User/TIMER/: timer.c
    ../Code_User/ADC/: adc.c
    ../Code_User/SPI/: spi.c
    ../Code_User/RF2G4/: rf2G4.c
    ../Code_User/DMA/: dma.c
  group FWLib
    ../FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_spi.c stm32f10x_dma.c
  group Core
    ../Core/: core_cm3.c startup_stm32f10x_md.s
  group System
    ../System/: stm32f10x_it.c system_stm32f10x.c
  group 例程说明
    ../: 例程说明.txt
